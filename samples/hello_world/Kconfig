## samples/hello_world/Kconfig
```kconfig
config CUSTOM_PATH
	string "variable with custom path"
	default "/home/user/custom"

source "Kconfig.zephyr"
```
